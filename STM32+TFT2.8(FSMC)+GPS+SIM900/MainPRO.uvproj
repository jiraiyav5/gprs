# Keil uVision project MainPRO.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MainHEX +hex
  c flags: oTime=1 OneElfS=1 wLevel=2
  c include: .;.\APP;.\uCOS-II\Source;.\uCOS-II\Ports;.\uC-CPU;.\FWL\inc;.\uC-LIB\Source;.\uC-LIB\Ports;.\uC-OSView\Source;.\uC-OSView\Ports;.\BSP;.\TFTDriver;.\GSM;.\GPS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\BSP\STM32_Flash.scat
  link misc: --entry ResetHndlr
  group Main
    ./APP/: app.c app_cfg.h includes.h os_cfg.h stm32f10x_conf.h vectors.s eeprom.c ASCII_Option.C TempTable.h IIC_API.C IIC_API.H
  group BSP
    ./BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c init.s
  group uC-GSM/Source
    ./GSM/: GSM_Tasks.c GSM_USER_API.C GSM_TXD.C GSM_RXD.C GSM_Processes.C GSM_COM_Driver.c GSM_GB2312_Unicode.c GSM.H GSM_Config.h GSM_Typedefine.h GSM_USER_API.H GSM_Processes.h GSM_TXD.H GSM_RXD.H
  group uC-GPS/Source
    ./GPS/: GPS.c GPS_COM_Driver.c GPS.h
  group TFTDriver
    ./TFTDriver/: TFTDriver.C TFTDriver.h ASCII_Lib.h GPSimage.h CNLib15x16.c CNLib15x16.h GT20L16P1Y.H GT20L16P1Y.C
  group FWL
    ./FWL/inc/: stm32f10x_type.h stm32f10x_map.h cortexm3_macro.h stm32f10x_adc.h stm32f10x_rcc.h
    ./FWL/: cortexm3_macro.s
    ./FWL/src/: stm32f10x_adc.c stm32f10x_rcc.c stm32f10x_lib.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_systick.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_nvic.c stm32f10x_sdio.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_i2c.c
  group uC-CPU
    ./uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_def.h
  group uC-OS-II/Source
    ./uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC-OS-II/Port
    ./uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC-LIB/Source
    ./uC-LIB/Source/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC-LIB/Port
    ./uC-LIB/Ports/: lib_mem_a.asm
  group uC-OSView/Source
    ./uC-OSView/Source/: os_view.c os_view.h
  group uC-OSView/Port
    ./uC-OSView/Ports/: os_viewc.c os_viewc.h
  group 调试笔记
    ./: 调试笔记.h
